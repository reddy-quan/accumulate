## Buildroot/test/Config.in
```kconfig
config BR2_PACKAGE_TEST
	bool "test"
	#depends on BR2_USE_MMU # fork()
	help
	  This is a test

	  http://www.test.org
```
